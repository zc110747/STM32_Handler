# Keil uVision project LowerBoard.uvprojx, settings and files
target LowerBoard (6160000::V6.16::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: LowerBoard +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../UsrDrivers/Inc;../FreeRTOS/include;../FreeRTOS/portable/ARM_CM4F;../Application/Inc;..\ff15\source;..\ThreadParts\SEGGER_RTT\RTT;..\ThreadParts\SEGGER_RTT\Config;..\ThreadParts\cm_backtrace;..\ThreadParts\DSP_LIB\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000200 size 0x2fe00
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c main.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_sdram.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rng.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers
    ../UsrDrivers/Src/: sdram.cpp driver.cpp lcd.cpp tpad.cpp rtc.cpp sdmmc.cpp spi.cpp led.c key.c usart.c adc.c dac.c rng.c i2c.c dfu_test.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/ARM_CM4F/: port.c
    ../FreeRTOS/MemMang/: heap_4.c
  group Application/User
    ../Application/Src/: application.cpp logger.cpp schedular.cpp i2c_monitor.cpp monitor.cpp
  group FATFS
    ../ff15/source/: diskio.c ff.c ffsystem.c ffunicode.c disk_interface.c
  group ThreadParts/SEGGER_RTT
    ../ThreadParts/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_printf.c
  group ThreadParts/cm_backtrace
    ../ThreadParts/cm_backtrace/: cm_backtrace.c
    ../ThreadParts/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group DSP_Lib
    ../ThreadParts/DSP_LIB/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.5.0
